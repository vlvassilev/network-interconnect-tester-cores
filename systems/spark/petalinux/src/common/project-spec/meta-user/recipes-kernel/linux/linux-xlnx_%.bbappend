SRC_URI += "file://user.cfg \
            file://axienet_common_mdio.patch \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

